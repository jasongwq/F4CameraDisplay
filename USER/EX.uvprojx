# Keil uVision project EX.uvprojx, settings and files
target CODE (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: EX +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM,__TARGET_FPU_VFP
  c include: ..\GLIB\Libraries\CMSIS\Include;..\GLIB\Libraries\CMSIS\ST\STM32F4xx\Include;..\GLIB\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\GLIB\HARDWARE;..\GLIB\SYSTEM;.\USER;..\GLIB\PERIPHERAL\LCD;.\USER\CONFIG;..\GLIB\PERIPHERAL\CAMERA;.\USER\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32_config.h stm32f4xx_it.c
    ./USER/APP/: User_Task.c
  group SYSTEM
    ../GLIB/SYSTEM/: sys.c usart.c sys_os.c minos_delay.c sys_usart.c
  group HARDWARE
    ../GLIB/HARDWARE/: gpio.c spi.c
  group PERIPHERAL
    ../GLIB/PERIPHERAL/LCD/: FSMC_TFT.c ILI93.c LCD.c
    ../GLIB/PERIPHERAL/CAMERA/: ov7670.c
    ../GLIB/PERIPHERAL/NRF24L01/: G32_Nrf24l01.C
    ../GLIB/PERIPHERAL/SD/: sdio_sdcard.c
  group APP
    ./USER/APP/: EasyTracer2.c data_transfer.c
  group FWLIB
    ../GLIB/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_wwdg.c
  group CORE
    ./USER/: system_stm32f4xx.c
    ../GLIB/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group FATFS
    ../GLIB/FATFS/exfuns/: exfuns.c
    ../GLIB/FATFS/src/: diskio.c ff.c
